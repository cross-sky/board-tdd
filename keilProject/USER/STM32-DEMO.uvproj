# Keil uVision project STM32-DEMO.uvproj, settings and files
target 3PMIN (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32-DEMO +hex
  c flags: Optim=1 oTime=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\CMSIS;..\USER;..\FWlib\inc;..\FWlib\src;..\..\UnityProject\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUPCODE
    ../CMSIS/startup/: startup_stm32f10x_md.s
  group FWlib
    ../FWlib/src/: stm32f10x_rcc.c stm32f10x_gpio.c misc.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group USER
    ../../UnityProject/src/USER/: adc_filter.c ErrType.c input_process.c IoDetectErr.c main.c queue_process.c RTdataStruct.c StateType.c stm32f10x_it.c task.c valve_calc.c
  group Bsp
    ../../UnityProject/src/BSP/: stm32_dma_uart2.c stm32_ub_adc.c stm32_ub_cd4051.c stm32_ub_dma_usart1.c stm32_ub_led.c stm32_ub_relay.c Tsystick.c
  group readme
    ./: readme.txt
